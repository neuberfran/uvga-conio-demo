# IAR project nec_uVGA.ewp, settings and files
configuration Debug (78000, debug)
  General.GHeapSize: 512
  ICC78000.CCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  A78000.ADefines: __STANDARD_MODEL__
  XLINK.XclFile: DF9222_V4.XCL
  XLINK.XlinkStackSize: 1
configuration Release (78000)
  as the first configuration, except:
  group (top)
    ../lib/: conio.c ui.c
    ./: hw_78k0s.c
    ../: main.c
