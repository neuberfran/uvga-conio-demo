# IAR project tms470.ewp, settings and files
configuration RAM (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: TMS470R1A128 TexasInstruments TMS470R1A128
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: tms470.srec
  ILINK.IlinkOutputFile: tms470.out
  ILINK.IlinkIcfFile: C:\projekty\microvga\uVGALib\tms470_iar\Configuration_Files\A128_Files\tms470r1a128_lnk_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Flash (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\Configuration_Files\A128_Files\
  ILINK.IlinkIcfFile: C:\projekty\microvga\uVGALib\tms470_iar\Configuration_Files\A128_Files\tms470r1a128_lnk_flash.icf
  group (top)
    ../lib/: conio.c ui.c
    ./: cstartup.s hw_tms470.c
    ../: main.c
