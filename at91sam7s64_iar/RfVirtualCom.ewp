# IAR project RfVirtualCom.ewp, settings and files
configuration Node A Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: AT91SAM7S64 Atmel AT91SAM7S64
  ICCARM.CCIncludePath2: app; board; modules; Include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: Include
  OBJCOPY.OOCOutputFile: microvga_at91sam7s.bin
  ILINK.IlinkOutputFile: RfVirtualCom.out
  ILINK.IlinkIcfFile: config\at91SAM7S64_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: Cstartup.s hw_at91sam7s.c
    ../: main.c
  group ConIOLib
    ../lib/: conio.c ui.c
