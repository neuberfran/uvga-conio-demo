# IAR project STR710-EVAL.ewp, settings and files
configuration debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STR712 ST STR712
  ICCARM.CCIncludePath2: include; library\inc\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: STR710-Eval.srec
  ILINK.IlinkOutputFile: STR710-Eval.out
  ILINK.IlinkIcfFile: linker\STR71x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RAM (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STR710 ST STR710
  ICCARM.CCIncludePath2: include
  ILINK.IlinkIcfFile: linker\STR71x_RAM.icf
  group (top)
    include/: 71x_conf.h
    ./: 71x_it.c hw_st710.c
    ../: main.c
  group startup
    startup/: 71x_init.s 71x_vect.s
  group STLib
    library/src/: 71x_apb.c 71x_gpio.c 71x_rccu.c 71x_uart.c
  group uVGALib
    ../lib/: conio.c ui.c
