# IAR project S2_test.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC2104 NXP LPC2104
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: __THUMB_LIBRARY__
  OBJCOPY.OOCOutputFile: S2_test.srec
  ILINK.IlinkOutputFile: S2_test.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\examples\NXP\LPC2103\Pasat\PHIL40-03-Uart\PHIL40-03_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: S2_test.hex
  ILINK.IlinkIcfFile: PHIL40-03_Flash.icf
  group (top)
    ../: aa.c main.c
    ./: hw_lpc21xx.c
  group uVGALib
    ../lib/: conio.c ui.c
